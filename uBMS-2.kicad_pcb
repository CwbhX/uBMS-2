# Repository CwbhX/uBMS-2 (continued)

## KiCad design uBMS-2.kicad_pcb (continued)

Board: 4 copper layers, 65.0 x 100.0 mm, 245 parts (40 on the bottom side), 179 nets.

File uBMS-2 BOM.xlsx (part):

Source: | C:\Users\Clement Hathaway\Github\uBMS-2\uBMS-2.sch
Date: | 44054.956064814818
Tool: | Eeschema (5.1.4)-1
Generator: | C:\Program Files\KiCad\bin\scripting\plugins/bom_csv_grouped_by_value.py
Component Count: | 183
Individual Components:
Item | Qty | Reference(s) | Value | LibPart | Footprint | Datasheet | Category | DK_Datasheet_Link | DK_Detail_Page | Description | Digi-Key_PN | Family | MPN | Manufacturer | Manufacturer Part | Status | Vendor | Vendor Part
 |  | BTN1 | Reset | Lafayette_Electric_Car_Internals:PushButton | Button_Switch_SMD:PTS636_SM43_SMTR_LFS_6mm_3,5mm | https://media.digikey.com/pdf/Data%20Sheets/RAFI%20PDF's/Rac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 |  |  |  |  |  |  |  | RAFI USA | 1.14100.5030000 |  | Digikey | 1715-1676-1-ND
 |  | BTN2 | Program | Lafayette_Electric_Car_Internals:PushButton | Button_Switch_SMD:PTS636_SM43_SMTR_LFS_6mm_3,5mm | https://media.digikey.com/pdf/Data%20Sheets/RAFI%20PDF's/Rac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 |  |  |  |  |  |  |  | RAFI USA | 1.14100.5030000 |  | Digikey | 1715-1676-1-ND
 |  | BTN3 | Input_1 | Lafayette_Electric_Car_Internals:PushButton | Button_Switch_SMD:PTS636_SM43_SMTR_LFS_6mm_3,5mm | https://media.digikey.com/pdf/Data%20Sheets/RAFI%20PDF's/Rac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 |  |  |  |  |  |  |  | RAFI USA | 1.14100.5030000 |  | Digikey | 1715-1676-1-ND
 |  | BTN4 | Input_2 | Lafayette_Electric_Car_Internals:PushButton | Button_Switch_SMD:PTS636_SM43_SMTR_LFS_6mm_3,5mm | https://media.digikey.com/pdf/Data%20Sheets/RAFI%20PDF's/Rac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 |  |  |  |  |  |  |  | RAFI USA | 1.14100.5030000 |  | Digikey | 1715-1676-1-ND
 |  | C1 | 0.1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C2 | 10uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C3 | 0.1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C4 | 0.1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C5 | 2.2uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C6 | 1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C7 | 1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C8 | 0.1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C9 | 0.1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C10 | 0.1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C11 | 0.1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C12 | 0.1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C13 | 0.1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C14 | 0.1uF | Device:C_Small | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C15 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C16 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C17 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C18 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C19 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C20 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C21 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C22 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C23 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C24 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C25 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | C26 | 10nF | Device:C | Capacitor_SMD:C_1206_3216Metric | ~
 |  | CIN1 | 100uF 60V | Device:C_Small | Capacitor_SMD:CP_Elec_10x10 | ~
 |  | COUT1 | 1000uF | Device:C_Small | Capacitor_SMD:CP_Elec_10x10 | ~
 |  | D1 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D2 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D3 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D4 | CLX6F-FKC | uBMS-Parts:CLX6F-FKC | LED_SMD:LED_RGB_PLCC-6 | ttps://www.cree.com/led-components/media/documents/ds-CLX6F-FKC-1352.pdf
 |  | D5 | LED | Device:LED | LED_SMD:LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder | ~
 |  | D6 | LED | Device:LED | LED_SMD:LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder | ~
 |  | D7 | LED | Device:LED | LED_SMD:LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder | ~
 |  | D8 | LED | Device:LED | LED_SMD:LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder | ~
 |  | D9 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D10 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D11 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D12 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D13 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D14 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D15 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D16 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D17 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D18 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D19 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | D20 | D | Device:D | Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder | ~
 |  | F1 | 1A PTC | Device:Fuse | Fuse:Fuse_2920_7451Metric_Pad2.10x5.45mm_HandSolder | ~
 |  | H1 | MountingHole | Mechanical:MountingHole | MountingHole:MountingHole_2mm | ~
 |  | H2 | MountingHole | Mechanical:MountingHole | MountingHole:MountingHole_2mm | ~
 |  | H3 | MountingHole | Mechanical:MountingHole | MountingHole:MountingHole_2mm | ~
 |  | H4 | MountingHole | Mechanical:MountingHole | MountingHole:MountingHole_2mm | ~
 |  | J1 | Conn_02x03_Counter_Clockwise | Connector_Generic:Conn_02x03_Counter_Clockwise | Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical_SMD | ~
 |  | J2 | Conn_01x02 | Connector_Generic:Conn_01x02 | uBMS-2:1720430202 | ~
 |  | J3 | Conn_01x01 | Connector_Generic:Conn_01x01 | MountingHole:MountingHole_3mm_Pad_Via | ~
 |  | J4 | Conn_01x01 | Connector_Generic:Conn_01x01 | TestPoint:TestPoint_Pad_D1.5mm | ~
 |  | J5 | Conn_02x07_Odd_Even | Connector_Generic:Conn_02x07_Odd_Even | uBMS-2:Molex_Milli_Grid_0878325623_TopBottom | ~
 |  | J6 | Conn_02x07_Odd_Even | Connector_Generic:Conn_02x07_Odd_Even | uBMS-2:Molex_Milli_Grid_0878325623_TopBottom | ~
 |  | J7 | Conn_02x07_Odd_Even | Connector_Generic:Conn_02x07_Odd_Even | uBMS-2:Molex_Milli_Grid_0878325623_TopBottom | ~
 |  | J8 | Conn_01x01 | Connector_Generic:Conn_01x01 | MountingHole:MountingHole_3mm_Pad_Via | ~
 |  | L1 | 100uH | Device:L | Inductor_SMD:L_12x12mm_H8mm | ~
 |  | Q1 | 2N7002 | Transistor_FET:2N7002 | Package_TO_SOT_SMD:SOT-23 | https://www.fairchildsemi.com/datasheets/2N/2N7002.pdf
 |  | Q2 | 2N7002 | Transistor_FET:2N7002 | Package_TO_SOT_SMD:SOT-23 | https://www.fairchildsemi.com/datasheets/2N/2N7002.pdf
 |  | Q3 | NTD5865NL | uBMS-Parts:NTD5865NL | Package_TO_SOT_SMD:TO-252-2 | https://www.onsemi.com/pub/Collateral/NTD5865NL-D.PDF
 |  | Q4 | FQD5N20L | uBMS-Parts:FQD5N20L | Package_TO_SOT_SMD:TO-252-2 | https://www.mouser.com/datasheet/2/149/FQD5N20L-266424.pdf
 |  | Q5 | FQD5N20L | uBMS-Parts:FQD5N20L | Package_TO_SOT_SMD:TO-252-2 | https://www.mouser.com/datasheet/2/149/FQD5N20L-266424.pdf
 |  | Q6 | FQD5N20L | uBMS-Parts:FQD5N20L | Package_TO_SOT_SMD:TO-252-2 | https://www.mouser.com/datasheet/2/149/FQD5N20L-266424.pdf
 |  | Q7 | FQD5N20L | uBMS-Parts:FQD5N20L | Package_TO_SOT_SMD:TO-252-2 | https://www.mouser.com/datasheet/2/149/FQD5N20L-266424.pdf
 |  | Q8 | FQD5N20L | uBMS-Parts:FQD5N20L | Package_TO_SOT_SMD:TO-252-2 | https://www.mouser.com/datasheet/2/149/FQD5N20L-266424.pdf
 |  | Q9 | FQD5N20L | uBMS-Parts:FQD5N20L | Package_TO_SOT_SMD:TO-252-2 | https://www.mouser.com/datasheet/2/149/FQD5N20L-266424.pdf
 |  | Q10 | FQD5N20L | uBMS-Parts:FQD5N20L | Package_TO_SOT_SMD:TO-252-2 | https://www.mouser.com/datasheet/2/149/FQD5N20L-266424.pdf
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
## Commit log

2020-06-27 Initial Files
2020-07-25 Added first component!
    ESP32 Wroom module with PS circuitry
2020-07-26 Added Programming & Reset Buttons
    Using info from:
    - https://esp32.com/viewtopic.php?f=2&t=10442
    - https://github.com/espressif/esptool/wiki/ESP32-Boot-Mode-Selection
    - https://www.espressif.com/sites/default/files/documentation/esp32-wroom-32_datasheet_en.pdf
2020-07-26 Added Buck Converter SMPS
2020-07-26 Added ADC Section
2020-07-26 Added I2C Level Shifter
    - Also connected I2C pins on ESP32
2020-07-27 Added Linear Voltage Regulator
2020-07-27 Added PWM Balance Ports on ESP
    - Runs in counterclock wise order around the chiplet with the antenna facing up
    - Avoiding using GPIO0 since it is a boot pin
    - Avoiding using DAC_1 incase I need to use it later
2020-07-27 Added current sense
    - Had to change the design to place the current sense amp after the module disconnect switch to prevent destruction of the amp
2020-07-27 Added current sense label
2020-07-27 Added Module Disconnect
2020-07-27 Added GPIO expander
2020-07-27 Fixed current sense
2020-07-27 Added 7 Seg & RGB Indicators
2020-07-27 Added battery indicator LEDs
2020-07-28 Added Mux Sheets
2020-07-29 Updated Current Sense Section + Added Fuse for PS
2020-07-29 Added pins to Hierarchical Sheets
2020-07-29 Work on Voltage Sheet
2020-07-29 Finished Voltage divider network
2020-07-29 Finished voltage sense sheet
2020-07-29 Finished Temp Sheet
2020-07-29 Wired up second GPIO expander and reset pins
2020-07-30 Finished Balance Sheet
2020-07-30 Connected Balance Sheet
2020-07-30 Think I just added labels?
2020-07-30 Added Micro SD Card Interface
2020-07-30 Fixed pull up for enable pin on GPIO
2020-07-30 Added buttons + redid numbering
2020-08-01 Added PCB temp sensors and redit numberings
2020-08-02 Added most footprints
2020-08-02 added card detect sd card stuff
2020-08-03 Switched to lower GPIO pin part to save space
2020-08-03 Created 7-seg footprint (local)
2020-08-03 Updated SD card adapter, again, for MEM2061
2020-08-03 Removed SD card Adapter, added programming port
2020-08-03 Added more power connectors
2020-08-03 Added ext ADC pin and fixed connection bugs
2020-08-03 Added JST power connect and fixed some footprints
2020-08-03 Redid programming port for 2x3 config
2020-08-03 Removed additional power connector
2020-08-03 Refactored some naming
2020-08-03 added main power connector
2020-08-03 Added new 14 pin connector footprint
2020-08-03 Updated balance connector
2020-08-04 Replaced Shunt resistor with normal resistor schematic symbol
2020-08-05 Using Molex Milli Grid Connector for 14 pin
2020-08-05 Fixed power connector footprint and 3d
2020-08-05 Laid out Balance Circuitry
2020-08-05 Added rounded corners and 2mm mounting holes
2020-08-06 Laid out components on PCB in semi-final state
2020-08-06 Fixed volt reg footprint, fill power planes, added high current paths
2020-08-07 routed and filled a bunch of stuff, so much more to do
2020-08-08 Routed a LOT more PCB traces
2020-08-08 Everything is finally routed
2020-08-08 Fixed connections
2020-08-09 Added Name and Logo
2020-08-09 Generated Gerbers for JLCPCB
2020-08-12 Created 3D model and BOM with priliminary pricing
2020-09-05 Added PDFs
2020-11-22 Fixed Vcc issue on MCP23008 to prevent shorting in schematic (NOT PCB)
    - Still need to add caps to the balance section
    - Update PCB
2020-11-27 Voltage Reg and PTC replacement and balance fet DS caps SCHEMATIC ONLY
    - Also added new fields to some of the new parts to make a more complete schematic, I'll slowly be adding this to the other components
    - Hopefully the new DC-DC has a MUCH smaller footprint
    - Need to fix ESP32 boot issue still
    - Need to prepare SMD XT60 Connectors
    - Need to remove RGB
    - Need to reduce brightness of status LEDs
2020-11-29 USB to UART & USB-C & Resized sheet to A3 & Parts List Markdown
    - Added Automatic programming circuitry with MOSFETs
    - Removed Button 2
    - Todo: Add Protection Diodes USB lines
    - Todo: Check if VBUS input to UART controller is 5v tolerant
2020-11-30 Annotated new symbols & Changed Buck Inductor and Freq & Added USB protection diodes
    - L1 is now 100uH rated for 1.1A
    - Switching freq is now 400kHz
    - Need to find proper specced input and output caps
    - Does VBus need 3.3v or 5v input?
    - R23 is now 71.5k
2020-12-01 Added XT-60 connector for power input and output on schematic
2020-12-01 Footprint and data maintence... and a couple values
    - PTC 300mA Fuse
    - TVS Diodes now have footprints and data
    - Red and Green USB Transmit LEDs now have footprints & data
    - Power Schottkey Diode from USB-C footprint n data
    - CP2102N-A02-GQFN24 footprint n data
    - Replaced old 2N7002 with the digikey variant with more data
2020-12-02 Added missing annotations & added USB-C Connector
    - Using KiCAD symbol for USB-C Connector but using proper footprint, I think pins should match up
2020-12-02 Updated all the caps (I think) mostly changed to 0805
    - Added 0603 footprints to new resistors which is slightly different from the old 0603 resistors for some reason???
    - Annotated the schematic
    - Still need to do the inductor oof
2020-12-02 Added inductor footprint
2020-12-03 Added Boot and Reset Switches
    - Also added no connects to the GPIO where the RGB led used to be connected
    - Changed buttons to a smaller button
2020-12-03 Fixed footprint name issue for button
2020-12-03 Organised the schematic
2020-12-03 Minor Update
    - Fixed button labels
2020-12-09 Reset 0604 resistors to smaller (older?) footprint size
2020-12-13 Replaced GPIO expanders with shift regs
    - Freed up unnessecary pins from the ESP by removing old UART signals
    - Started PCB layout
    - Replaced level shifter with fet arrat
    - Level shifter for shift reg inputs
    - Added more bat indicator LEDs
2020-12-13 Added Smaller 500mA PTC
2020-12-13 Placed most components
    - Make sure nets are properly connected especially with power rails from battery
2020-12-21 Finish PCB Layout Preliminary
    - Moved around temp connections to the analogue mux to help aid layout
    - Moved around voltage sense connections too
    - Moved around LED status shift reg
    - " and the 7 seg shift reg
    - Added filled copper layers
    - Removed external ADC Input
2020-12-21 Fixed disconnects and silkscreen
    - LOGOOOOO
2020-12-21 Fixed DRC Errors
2020-12-21 Added images
2020-12-21 Genreated Gerbers
2020-12-21 Remvoed Status Silkscreen msg
2020-12-21 Updated some properties and generated BOM with KiBOM
2020-12-22 Added more part info
    - also updated BOM
2021-01-20 Updated voltage issues for CP2102
    - Hopefully this fixes the murdering of this chip and it then shorting my 3v3 rail to 5v
2021-01-20 Updated voltage divider values
    - Also changed top R1 to R22 to match previous R22 that was there (try to retain pad layout)
2022-03-06 Update to KiCAD 6 files
2022-03-06 [V2.5] - Archived old documents in repo
2022-11-25 Updated project libraries to KiCAD 6
2022-11-26 Updated schematic, added ESP32-S2
2022-11-26 Add test points
2022-11-26 More schematic updates
2022-11-26 Updated all of component values
2022-11-27 DCDC Section Mostly complete
2022-11-27 More Layout!
2022-11-28 More Layout
2022-11-28 More updates!
2022-11-28 ALMOST THERE
2022-11-28 LAYOUT COMPLETE
2022-11-28 Basically Done
2022-11-28 Done V2.5
2022-11-28 Updated PCB and Gerbers for JLCPCB
2022-11-28 Updates to layout and PCBWay Gerbers
2024-07-01 Saved to KiCAD 8 format
