# Repository CwbhX/uBMS-2

## KiCad design uBMS-2.kicad_pcb

Parts:
C1, C3, C4, C6, C9, C10, C11, C38, C39, C40: 0.1uF; C_0402_1005Metric; Part Number CC0402KRX7R7BB104; Digikey Number 311-1338-1-ND
C2: 10uF; C_0805_2012Metric; Part Number C0805C106K8PACTU; Digikey Number 399-4925-2-ND
C5: 10nF; C_0402_1005Metric; Part Number GCM155R71H103KA55D; Digikey Number 490-4762-1-ND
C7, C8: 22pF; C_0402_1005Metric; Part Number GRM1555C1H220JA01D; Digikey Number 490-5868-1-ND
C50: 1uF; C_0805_2012Metric; Part Number C0805C105Z4VACTU; Digikey Number 399-8011-2-ND
D1: RB162VAM-20TR; D_TUMD2; Part Number RB162VAM-20TR; Digikey Number RB162VAM-20TRTR-ND
D2, D7, D22, D24, D25: GREEN_LED; LED_0603_1608Metric; Part Number 150060VS55040; Digikey Number 732-12017-2-ND
D4, D8, D21: TPD1E10B06QDPYRQ1; D_0402_1005Metric; Part Number TPD1E10B06QDPYRQ1; Digikey Number 296-TPD1E10B06QDPYRQ1TR-ND
D5: RED_LED; LED_0603_1608Metric; Part Number 150060SS55040; Digikey Number 732-12016-2-ND
D6, D23: YELLOW_LED; LED_0603_1608Metric; Part Number 150060YS55040; Digikey Number 732-12018-2-ND
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.5mm_Pad_TopBottom
J1: DX07S016JA1R1500; PARTREV 1; Digikey Number 670-DX07S016JA1R1500TR-ND
J2, J3: XT60PW-M20
Q3: NTD5865NL; TO-252-2; Part Number NTD5865NLT4G; Digikey Number NTD5865NLT4GOSTR-ND
R1: 10k; R_0402_1005Metric; Part Number RC0402FR-0710KL; Digikey Number 311-10.0KLRCT-ND
R2, R3: 27R; R_0402_1005Metric; Part Number RC0402FR-0727RL; Digikey Number YAG3086CT-ND
R7: 1m Ohm; R_2512_CSNL2512; Part Number CSNL2512FT1L00; Digikey Number CSNL2512FT1L00TR-ND
R8: 470R; R_0402_1005Metric; Part Number RC0402FR-07470RL; Digikey Number 311-470LRCT-ND
R10, R11, R12, R13, R14, R15, R16, R17, R18: 330R; R_0402_1005Metric; Part Number RC0402FR-07330RL; Digikey Number 311-330LRCT-ND
R19, R25, R26, R27, R28, R89, R90, R101: 1k; R_0402_1005Metric; Part Number RC0402FR-071KL; Digikey Number 311-1.00KLRCT-ND
R20, R29: 4.7k; R_0402_1005Metric; Part Number RC0402FR-074K7L; Digikey Number 311-4.7KLRCT-ND
R22: 47k; R_0402_1005Metric; Part Number RC0402FR-0747KL; Digikey Number 311-47.0KLRCT-ND
R30, R88: 5.1k; R_0402_1005Metric; Part Number RC0402FR-075K1L; Digikey Number 311-5.10KLRCT-ND
R106: 91k; R_0402_1005Metric; Part Number RC0402FR-0791KL; Digikey Number 311-91.0KLRCT-ND
SW1, SW2, SW3: PTS815_SJK_250_SMTR_LFS; Part Number PTS815_SJK_250_SMTR_LFS; Digikey Number CKN12216-2-ND
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26: TestPoint; TestPoint_Pad_D1.0mm
U1: ESP32-S2-MINI-1
U2: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm; Part Number ADS1115IDGSR; Digikey Number 296-38849-2-ND
U4: TL431DBZ; SOT-23; Part Number TL431ACDBZR
U6: TSC2012IDT; SO-8_3.9x4.9mm_P1.27mm; Part Number TSC2012IDT; Digikey Number 497-TSC2012IDTTR-ND
U7, U8: SN74HC595BRWNR; QFN40P250X250X50-17N
U9: VDMG10C0; Part Number VDMG10C0; Digikey Number VDMG10C0TR-ND
U13: SN74HC595BRWNR; QFN40P250X250X50-17N; Part Number SN74HC595BRWNR; Digikey Number 296-44070-2-ND

Connections:
+3V3: C2.1, C3.1, C5.1, R1.1, R20.2, TP25.1, U1.3 (3V3); also elsewhere on the board
+5V: C1.1, C9.1, C10.1, C11.1, C40.1, D1.1 (K), R8.1, TP23.1, U2.8 (VDD), U6.6 (Vcc), U7.16 (VCC), U8.16 (VCC), U13.16 (VCC); also elsewhere on the board
/7A: R11.2, U7.7 (QH)
/7B: R12.2, U7.15 (QA)
/7C: R13.2, U7.2 (QC)
/7D: R14.2, U7.3 (QD)
/7DP: R18.2, U7.1 (QB)
/7E: R15.2, U7.4 (QE)
/7F: R16.2, U7.6 (QG)
/7G: R17.2, U7.5 (QF)
/ADC_RDY_3V3: U1.38 (IO42); also elsewhere on the board
/ADC_RDY_5V: U2.2 (ALERT/RDY); also elsewhere on the board
/BTN_1: C4.1, R29.2, SW1.3, SW1.4, U1.36 (IO40)
/Batt_Pos: J3.2, R7.2, U6.8 (IN+); also elsewhere on the board
/CurrentSense: U2.6 (AIN2), U6.5 (OUT)
/ESP_EN: C39.1, R1.2, SW3.1, SW3.2, TP22.1, U1.45 (EN)
/ESP_IO0: C38.1, SW2.1, SW2.2, TP20.1, U1.4 (IO0)
/LED_BAT_G1: R90.1, U8.7 (QH)
/LED_BAT_G2: R89.1, U8.6 (QG)
/LED_BAT_G3: R28.1, U8.5 (QF)
/LED_BAT_G4: R27.1, U8.4 (QE)
/LED_BAT_R: R19.1, U8.1 (QB)
/LED_BAT_Y1: R26.1, U8.3 (QD)
/LED_BAT_Y2: R25.1, U8.2 (QC)
/MOD_DSC_G: R10.2, TP24.1, U1.21 (IO17)
/PWM_Blnce_1: TP4.1, U1.5 (IO1); also elsewhere on the board
/PWM_Blnce_2: TP5.1, U1.6 (IO2); also elsewhere on the board
/PWM_Blnce_3: TP6.1, U1.7 (IO3); also elsewhere on the board
/PWM_Blnce_4: TP7.1, U1.8 (IO4); also elsewhere on the board
/PWM_Blnce_5: TP8.1, U1.9 (IO5); also elsewhere on the board
/PWM_Blnce_6: TP9.1, U1.10 (IO6); also elsewhere on the board
/PWM_Blnce_7: TP10.1, U1.15 (IO11); also elsewhere on the board
/PWM_Blnce_8: TP11.1, U1.14 (IO10); also elsewhere on the board
/PWM_Blnce_9: TP12.1, U1.11 (IO7); also elsewhere on the board
/PWM_Blnce_10: TP13.1, U1.18 (IO14); also elsewhere on the board
/PWM_Blnce_11: TP14.1, U1.17 (IO13); also elsewhere on the board
/PWM_Blnce_12: TP15.1, U1.16 (IO12); also elsewhere on the board
/RCLK_3V3: U1.34 (IO38); also elsewhere on the board
/RCLK_5V: U7.12 (RCLK), U8.12 (RCLK), U13.12 (RCLK); also elsewhere on the board
/REF_2.5: R8.2, U4.1 (K), U4.2 (REF), U6.3 (REF2), U6.7 (REF1)
/S0_T: U13.1 (QB); also elsewhere on the board
/S0_V: U13.7 (QH); also elsewhere on the board
/S1_T: U13.15 (QA); also elsewhere on the board
/S1_V: U13.6 (QG); also elsewhere on the board
/S2_T: U13.2 (QC); also elsewhere on the board
/S2_V: U13.4 (QE); also elsewhere on the board
/S3_T: U13.3 (QD); also elsewhere on the board
/S3_V: U13.5 (QF); also elsewhere on the board
/SCL_3V3: TP18.1, U1.13 (IO9); also elsewhere on the board
/SCL_5V: U2.10 (SCL); also elsewhere on the board
/SDA_3V3: TP16.1, U1.12 (IO8); also elsewhere on the board
/SDA_5V: U2.9 (SDA); also elsewhere on the board
/SER_3V3: U1.33 (IO37); also elsewhere on the board
/SER_5V: U7.14 (SER); also elsewhere on the board
/SRCLK_3V3: U1.32 (IO36); also elsewhere on the board
/SRCLK_5V: U7.11 (SRCLK), U8.11 (SRCLK), U13.11 (SRCLK); also elsewhere on the board
/SREG_1_OUT: U7.9 (QH'), U8.14 (SER)
/SREG_2_OUT: U8.9 (QH'), U13.14 (SER)
/SYS_Pos: J2.2, R7.1, U6.1 (IN-)
/SYS_RTN: J2.1, Q3.2 (D)
/TMUX_EN: U1.19 (IO15); also elsewhere on the board
/TempSense: U2.5 (AIN1); also elsewhere on the board
/UART_RX: TP2.1, U1.40 (RXD0)
/UART_TX: TP1.1, U1.39 (TXD0)
/UBER_EN: U1.37 (IO41); also elsewhere on the board
/USB_D+: R3.1, U1.24 (IO20)
/USB_D-: R2.1, U1.23 (IO19)
/USB_D_UT+: C8.1, D4.1 (K), J1.6 (D+), J1.7 (D+), R3.2
/USB_D_UT-: C7.1, D8.1 (K), J1.5 (D-), J1.8 (D-), R2.2
/VBUS: C50.1, D1.2 (A), D21.1 (K), J1.2 (VBUS), J1.11 (VBUS), R22.1, R101.1
/VBUS_3V3: C6.1, R22.2, R106.1, U1.25 (IO21)
/VMUX_EN: U1.20 (IO16); also elsewhere on the board
/VoltageSense: U2.4 (AIN0); also elsewhere on the board
/~OE_3V3: U1.35 (IO39); also elsewhere on the board
/~OE_5V: U7.13 (~OE), U8.13 (~OE), U13.13 (~OE); also elsewhere on the board
/~SRCLR_3V3: U1.31 (IO35); also elsewhere on the board
/~SRCLR_5V: U7.10 (~SRCLR), U8.10 (~SRCLR), U13.10 (~SRCLR); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C38.2, C39.2, C40.2, C50.2, D2.1 (K), D4.2 (A), D5.1 (K), D6.1 (K), D7.1 (K), D8.2 (A), D21.2 (A), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), H1.1, H2.1, H3.1, H4.1, J1.1 (GND), J1.12 (GND), J1.S1 (SHIELD), J1.S2 (SHIELD), J1.S3 (SHIELD), J1.S4 (SHIELD), J1.S5 (SHIELD), J1.S6 (SHIELD), J3.1, Q3.3 (S), R29.1, R30.1, R88.2, R106.2, SW2.3, SW2.4, SW3.3, SW3.4, TP17.1, TP19.1, TP21.1, U1.1 (GND), U1.2 (GND), U1.30 (GND), U1.42 (GND), U1.43 (GND), U1.46 (GND), U1.47 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U1.53 (GND), U1.54 (GND), U1.55 (GND), U1.56 (GND), U1.57 (GND), U1.58 (GND), U1.59 (GND), U1.60 (GND), U1.61 (GND), U1.62 (GND), U1.63 (GND), U1.64 (GND), U1.65 (GND), U1.66 (GND), U1.67 (GND), U1.68 (GND), U1.69 (GND)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; also elsewhere on the board
unnamed: D2.2 (A), R101.2
unnamed: D5.2 (A), R19.2
unnamed: D6.2 (A), R26.2
unnamed: D7.2 (A), R27.2
unnamed: D22.2 (A), R28.2
unnamed: D23.2 (A), R25.2
unnamed: D24.2 (A), R89.2
unnamed: D25.2 (A), R90.2
unnamed: J1.3 (CC1), R88.1
unnamed: J1.9 (CC2), R30.2
unnamed: Q3.1 (G), R10.1
unnamed: R11.1, U9.7 (A)
unnamed: R12.1, U9.6 (B)
unnamed: R13.1, U9.4 (C)
unnamed: R14.1, U9.2 (D)
unnamed: R15.1, U9.1 (E)
unnamed: R16.1, U9.9 (F)
unnamed: R17.1, U9.10 (G)
unnamed: R18.1, U9.5 (DP)
unnamed: R20.1, SW1.1, SW1.2
unnamed: TP3.1, U1.44 (IO46)
unnamed: TP26.1, U1.41 (IO45)

Notes on the sheet:
IO26 Unavailable with PSRAM Variant
To: System +/-
ESP32-S2
Shift Reg & Voltage & Temp Sense
Mounting Holes
Level Shifter
Test Points
Module Disconnect
Shift Register Indicators
To: Whatever
GND Connections
Buttons
Enable Button
Connectors
Batt Indicators
Boot Button
To: Bat +/-
PWM Balance Circuitry
ADDR: 0x48
USB-C & UART
7-Segment
Power
Termination Near MCU
External ADC - 16-bit
Bridge for Power Input
TSV
Current Sense

Parts:
C13: 0.1uF; C_0402_1005Metric; Part Number CC0402KRX7R7BB104; Digikey Number 311-1338-1-ND
J5: Conn_02x07_Odd_Even; Molex_Milli_Grid_0878325623_TopBottom; Part Number 0878325623; Digikey Number WM6815TR-ND
R31, R37: 360k; R_0402_1005Metric; Part Number RC0402FR-07360KL; Digikey Number 311-360KLRCT-ND
R32: 200k; R_0402_1005Metric; Part Number RC0402FR-07200KL; Digikey Number 311-200KLRCT-ND
R33, R48: 330k; R_0402_1005Metric; Part Number RC0402JR-07330KL; Digikey Number 311-330KJRCT-ND
R34, R35, R46, R49: 499k; R_0402_1005Metric; Part Number RC0402FR-07499KL; Digikey Number 311-499KLRCT-ND
R36, R45, R47: 560k; R_0402_1005Metric; Part Number RC0402FR-07560KL; Digikey Number 311-560KLRCT-ND
R38, R39, R40, R41: 100k; R_0402_1005Metric; Part Number RC0402FR-07100KL; Digikey Number 311-100KLRCT-ND
R42, R44: 47k; R_0402_1005Metric; Part Number RC0402FR-0747KL; Digikey Number 311-47.0KLRCT-ND
R43: 24.9k; R_0402_1005Metric; Part Number RC0402FR-0724K9L; Digikey Number 311-24.9KLRCT-ND
R50: 147k; R_0402_1005Metric; Part Number RC0402FR-07147KL; Digikey Number YAG2981CT-ND
R51, R55: 39.2k; R_0402_1005Metric; Part Number RC0402FR-0739K2L; Digikey Number 311-39.2KLRCT-ND
R52, R53, R54, R107: 30k; R_0402_1005Metric; Part Number RC0402FR-0730KL; Digikey Number 311-30.0KLRCT-ND
R56, R57: 33.2k; R_0402_1005Metric; Part Number RC0402FR-0733K2L; Digikey Number 311-33.2KLRCT-ND
R58: 16.2k; R_0402_1005Metric; Part Number RC0402FR-0716K2L; Digikey Number 311-16.2KLRCT-ND
R59: 47.5k; R_0402_1005Metric; Part Number RC0402FR-0747K5L; Digikey Number 311-47.5KLRCT-ND
U10: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm; Part Number CD74HC4067SM96; Digikey Number 296-9226-2-ND

Connections:
+5V: C13.1, U10.24 (VCC); also elsewhere on the board
/S0_V: U10.10 (S0); also elsewhere on the board
/S1_V: U10.11 (S1); also elsewhere on the board
/S2_V: U10.14 (S2); also elsewhere on the board
/S3_V: U10.13 (S3); also elsewhere on the board
/VMUX_EN: U10.15 (~E); also elsewhere on the board
/VoltageMultiplex/Cell1_P: J5.2, U10.7 (I2)
/VoltageMultiplex/Cell2_P: J5.3, R31.1
/VoltageMultiplex/Cell2_Sense: R31.2, R37.1, U10.8 (I1)
/VoltageMultiplex/Cell3_P: J5.4, R32.1
/VoltageMultiplex/Cell3_Sense: R32.2, R38.1, U10.6 (I3)
/VoltageMultiplex/Cell4_P: J5.5, R33.1
/VoltageMultiplex/Cell4_Sense: R33.2, R39.1, U10.9 (I0)
/VoltageMultiplex/Cell5_P: J5.6, R34.1
/VoltageMultiplex/Cell5_Sense: R34.2, R40.1, U10.5 (I4)
/VoltageMultiplex/Cell6_P: J5.7, R35.1
/VoltageMultiplex/Cell6_Sense: R35.2, R41.1, U10.20 (I11)
/VoltageMultiplex/Cell7_P: J5.8, R36.1
/VoltageMultiplex/Cell7_Sense: R36.2, R42.1, U10.4 (I5)
/VoltageMultiplex/Cell8_P: J5.9, R45.1
/VoltageMultiplex/Cell8_Sense: R45.2, R51.1, U10.21 (I10)
/VoltageMultiplex/Cell9_P: J5.10, R46.1
/VoltageMultiplex/Cell9_Sense: R46.2, R52.1, U10.3 (I6)
/VoltageMultiplex/Cell10_P: J5.11, R47.1
/VoltageMultiplex/Cell10_Sense: R47.2, R53.1, U10.22 (I9)
/VoltageMultiplex/Cell11_P: J5.12, R48.1
/VoltageMultiplex/Cell11_Sense: R50.2, R59.1, U10.2 (I7)
/VoltageMultiplex/Cell12_P: J5.13, R49.1
/VoltageMultiplex/Cell12_Sense: R49.2, R54.1, U10.23 (I8)
/VoltageSense: U10.1 (COM); also elsewhere on the board
GND: C13.2, J5.1, J5.14, R37.2, R38.2, R39.2, R41.2, R43.2, R44.2, R55.2, R56.2, R57.2, R58.2, R59.2, R107.2, U10.12 (GND); also elsewhere on the board
unnamed: R40.2, R43.1
unnamed: R42.2, R44.1
unnamed: R48.2, R50.1
unnamed: R51.2, R55.1
unnamed: R52.2, R56.1
unnamed: R53.2, R57.1
unnamed: R54.2, R58.1
unnamed: R107.1, U10.16 (I15), U10.17 (I14), U10.18 (I13), U10.19 (I12)

Notes on the sheet:
* Through resistance of Analogue Mux is around 60 Ohms and connects to ADC which has input impedence of about 10M Ohm

Parts:
C14: 0.1uF; C_0402_1005Metric; Part Number CC0402KRX7R7BB104; Digikey Number 311-1338-1-ND
J6: Conn_02x07_Odd_Even; Molex_Milli_Grid_0878325623_TopBottom; Part Number 0878325623; Digikey Number WM6815TR-ND
R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71: 22k; R_0402_1005Metric; Part Number RC0402FR-0722KL; Digikey Number 311-22.0KLRCT-ND
R72, R73, R74, R75: 4.7k; R_0402_1005Metric; Part Number RC0402FR-074K7L; Digikey Number 311-4.7KLRCT-ND
TH1, TH2, TH3, TH4: 10k; R_0402_1005Metric; Part Number NTCG103JF103FT1; Digikey Number 445-2550-1-ND
U11: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm; Part Number CD74HC4067SM96; Digikey Number 296-9226-2-ND

Connections:
+5V: C14.1, J6.13, J6.14, TH1.1, TH2.1, TH3.1, TH4.1, U11.24 (VCC); also elsewhere on the board
/S0_T: U11.10 (S0); also elsewhere on the board
/S1_T: U11.11 (S1); also elsewhere on the board
/S2_T: U11.14 (S2); also elsewhere on the board
/S3_T: U11.13 (S3); also elsewhere on the board
/TMUX_EN: U11.15 (~E); also elsewhere on the board
/TempMultiplex/Balance_Temp: R73.1, TH2.2, U11.22 (I9)
/TempMultiplex/CellTemp_1: J6.1, R60.1, U11.16 (I15)
/TempMultiplex/CellTemp_2: J6.2, R61.1, U11.9 (I0)
/TempMultiplex/CellTemp_3: J6.3, R62.1, U11.17 (I14)
/TempMultiplex/CellTemp_4: J6.4, R63.1, U11.8 (I1)
/TempMultiplex/CellTemp_5: J6.5, R64.1, U11.18 (I13)
/TempMultiplex/CellTemp_6: J6.6, R65.1, U11.7 (I2)
/TempMultiplex/CellTemp_7: J6.7, R66.1, U11.19 (I12)
/TempMultiplex/CellTemp_8: J6.8, R67.1, U11.6 (I3)
/TempMultiplex/CellTemp_9: J6.9, R68.1, U11.20 (I11)
/TempMultiplex/CellTemp_10: J6.10, R69.1, U11.5 (I4)
/TempMultiplex/CellTemp_11: J6.11, R70.1, U11.21 (I10)
/TempMultiplex/CellTemp_12: J6.12, R71.1, U11.4 (I5)
/TempMultiplex/ESP_Temp: R75.1, TH4.2, U11.23 (I8)
/TempMultiplex/Mosfet_Temp: R72.1, TH1.2, U11.3 (I6)
/TempMultiplex/Power_Temp: R74.1, TH3.2, U11.2 (I7)
/TempSense: U11.1 (COM); also elsewhere on the board
GND: C14.2, R60.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, R67.2, R68.2, R69.2, R70.2, R71.2, R72.2, R73.2, R74.2, R75.2, U11.12 (GND); also elsewhere on the board

Notes on the sheet:
* Through resistance of Analogue Mux is around 60 Ohms and connects to ADC which has input impedence of about 10M Ohm

Parts:
C12, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37: 10nF; C_0402_1005Metric; Part Number GCM155R71H103KA55D; Digikey Number 490-4762-1-ND
D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20: D; D_1206_3216Metric; Part Number SD1206S020S1R0; Digikey Number 478-7803-1-ND
J7: Conn_02x07_Odd_Even; Molex_Milli_Grid_0878325623_TopBottom; Part Number 0878325623; Digikey Number WM6815TR-ND
Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15: FQD5N20L; TO-252-2; Part Number FQD5N20LTM; Digikey Number FQD5N20LTMTR-ND
R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87: 100k; R_1206_3216Metric; Part Number RC1206FR-13100KL; Digikey Number 13-RC1206FR-13100KLCT-ND

Connections:
/BatteryBalance/Cell1_P: C12.1, C23.2, D10.2 (A), J7.1, Q4.2 (D), Q5.3 (S), R77.2
/BatteryBalance/Cell2_P: C23.1, C29.2, D11.2 (A), J7.2, Q5.2 (D), Q6.3 (S), R78.2
/BatteryBalance/Cell3_P: C29.1, C35.2, D12.2 (A), J7.4, Q6.2 (D), Q7.3 (S), R79.2
/BatteryBalance/Cell4_P: C18.2, C35.1, D13.2 (A), J7.5, Q7.2 (D), Q8.3 (S), R80.2
/BatteryBalance/Cell5_P: C18.1, C24.2, D14.2 (A), J7.6, Q8.2 (D), Q9.3 (S), R81.2
/BatteryBalance/Cell6_P: C24.1, C30.2, D15.2 (A), J7.7, Q9.2 (D), Q10.3 (S), R82.2
/BatteryBalance/Cell7_P: C30.1, C36.2, D16.2 (A), J7.8, Q10.2 (D), Q11.3 (S), R83.2
/BatteryBalance/Cell8_P: C19.2, C36.1, D17.2 (A), J7.9, Q11.2 (D), Q12.3 (S), R84.2
/BatteryBalance/Cell9_P: C19.1, C25.2, D18.2 (A), J7.10, Q12.2 (D), Q13.3 (S), R85.2
/BatteryBalance/Cell10_P: C25.1, C31.2, D19.2 (A), J7.12, Q13.2 (D), Q14.3 (S), R86.2
/BatteryBalance/Cell11_P: C31.1, C37.2, D20.2 (A), J7.14, Q14.2 (D), Q15.3 (S), R87.2
/BatteryBalance/Cell12_P: C37.1, J7.13, Q15.2 (D)
/PWM_Blnce_1: C15.2; also elsewhere on the board
/PWM_Blnce_2: C20.2; also elsewhere on the board
/PWM_Blnce_3: C26.2; also elsewhere on the board
/PWM_Blnce_4: C32.2; also elsewhere on the board
/PWM_Blnce_5: C16.2; also elsewhere on the board
/PWM_Blnce_6: C21.2; also elsewhere on the board
/PWM_Blnce_7: C27.2; also elsewhere on the board
/PWM_Blnce_8: C33.2; also elsewhere on the board
/PWM_Blnce_9: C17.2; also elsewhere on the board
/PWM_Blnce_10: C22.2; also elsewhere on the board
/PWM_Blnce_11: C28.2; also elsewhere on the board
/PWM_Blnce_12: C34.2; also elsewhere on the board
GND: C12.2, D9.2 (A), J7.3, Q4.3 (S), R76.2; also elsewhere on the board
unnamed: C15.1, D9.1 (K), Q4.1 (G), R76.1
unnamed: C16.1, D13.1 (K), Q8.1 (G), R80.1
unnamed: C17.1, D17.1 (K), Q12.1 (G), R84.1
unnamed: C20.1, D10.1 (K), Q5.1 (G), R77.1
unnamed: C21.1, D14.1 (K), Q9.1 (G), R81.1
unnamed: C22.1, D18.1 (K), Q13.1 (G), R85.1
unnamed: C26.1, D11.1 (K), Q6.1 (G), R78.1
unnamed: C27.1, D15.1 (K), Q10.1 (G), R82.1
unnamed: C28.1, D19.1 (K), Q14.1 (G), R86.1
unnamed: C32.1, D12.1 (K), Q7.1 (G), R79.1
unnamed: C33.1, D16.1 (K), Q11.1 (G), R83.1
unnamed: C34.1, D20.1 (K), Q15.1 (G), R87.1

Parts:
C51, C52: 0.1uF; C_0402_1005Metric; Part Number CC0402KRX7R7BB104; Digikey Number 311-1338-1-ND
R9: 10k; R_0402_1005Metric; Part Number RC0402FR-0710KL; Digikey Number 311-10.0KLRCT-ND
R21, R23, R24, R91: 4.7k; R_0402_1005Metric; Part Number RC0402FR-074K7L; Digikey Number 311-4.7KLRCT-ND
U12: TXS0108EPW; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
+3V3: C51.1, R21.2, R23.2, U12.2 (VCCA); also elsewhere on the board
+5V: C52.1, R24.2, R91.2, U12.19 (VCCB); also elsewhere on the board
/ADC_RDY_3V3: U12.4 (A3); also elsewhere on the board
/ADC_RDY_5V: U12.17 (B3); also elsewhere on the board
/RCLK_3V3: U12.6 (A5); also elsewhere on the board
/RCLK_5V: U12.15 (B5); also elsewhere on the board
/SCL_3V3: R21.1, U12.1 (A1); also elsewhere on the board
/SCL_5V: R91.1, U12.20 (B1); also elsewhere on the board
/SDA_3V3: R23.1, U12.3 (A2); also elsewhere on the board
/SDA_5V: R24.1, U12.18 (B2); also elsewhere on the board
/SER_3V3: U12.7 (A6); also elsewhere on the board
/SER_5V: U12.14 (B6); also elsewhere on the board
/SRCLK_3V3: U12.8 (A7); also elsewhere on the board
/SRCLK_5V: U12.13 (B7); also elsewhere on the board
/UBER_EN: R9.1, U12.10 (OE); also elsewhere on the board
/~OE_3V3: U12.5 (A4); also elsewhere on the board
/~OE_5V: U12.16 (B4); also elsewhere on the board
/~SRCLR_3V3: U12.9 (A8); also elsewhere on the board
/~SRCLR_5V: U12.12 (B8); also elsewhere on the board
GND: C51.2, C52.2, R9.2, U12.11 (GND); also elsewhere on the board

Parts:
C41: 2.2uF; C_1206_3216Metric; Part Number HMK316AC7225KL-TE; Digikey Number 587-5026-2-ND
C42: 33nF; C_0402_1005Metric; Part Number CC0402KRX7R9BB332; Digikey Number 311-1034-1-ND
C43: 47uF; C_1206_3216Metric; Part Number JMK316ABJ476MLHT; Digikey Number 587-3399-2-ND
C44: 2.2uF; C_0402_1005Metric; Part Number GRM155C81C225ME15D; Digikey Number 490-10444-1-ND
C45, C48: 0.1uF; C_0402_1005Metric; Part Number CC0402KRX7R7BB104; Digikey Number 311-1338-1-ND
C46, C47: 1uF; C_0805_2012Metric; Part Number C0805C105Z4VACTU; Digikey Number 399-8011-2-ND
C49: 10nF; C_0402_1005Metric; Part Number GCM155R71H103KA55D; Digikey Number 490-4762-1-ND
D3, D26: GREEN_LED; LED_0603_1608Metric; Part Number 150060VS55040; Digikey Number 732-12017-2-ND
F1: 500mA PTC; 0ZCJ0050FF2G_3216X125N; Part Number 0ZCJ0050FF2G; Digikey Number 507-1802-2-ND
L1: 100uH; 1267AY-101M=P3; Part Number 1267AY-101M=P3; Digikey Number 490-10826-2-ND
R4: 10k; R_0402_1005Metric; Part Number RC0402FR-0710KL; Digikey Number 311-10.0KLRCT-ND
R5: 71.5k; R_0402_1005Metric; Part Number RC0402FR-0771K5L; Digikey Number YAG3222CT-ND
R6: 105k; R_0402_1005Metric; Part Number RC0402FR-07105KL; Digikey Number YAG2946CT-ND
R102, R103: 1k; R_0402_1005Metric; Part Number RC0402FR-071KL; Digikey Number 311-1.00KLRCT-ND
U3: LM5166X; Texas_S-PVSON-N10_ThermalVias; Part Number LM5166XDRCR; Digikey Number 296-47662-2-ND
U5: TLV1117-33; SOT-223-3_TabPin2; Part Number TLV1117LV33DCYR; Digikey Number 296-28778-2-ND

Connections:
+3V3: C47.1, C48.1, C49.1, R103.1, U5.2 (VO); also elsewhere on the board
+5V: C43.1, C44.1, C45.1, C46.1, L1.2, R4.1, R102.1, U3.8 (VOUT), U5.3 (VI); also elsewhere on the board
/Batt_Pos: F1.2; also elsewhere on the board
/Power/FUSED_V_IN: C41.1, F1.1, U3.2 (VIN), U3.7 (EN)
GND: C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, D3.1 (K), D26.1 (K), R5.2, R6.1, U3.9 (HYS), U3.10 (GND), U3.11 (PAD), U5.1 (GND); also elsewhere on the board
unnamed: C42.1, U3.4 (SS)
unnamed: D3.2 (A), R102.2
unnamed: D26.2 (A), R103.2
unnamed: L1.1, U3.1 (SW)
unnamed: R4.2, U3.6 (PGOOD)
unnamed: R5.1, U3.5 (RT)
unnamed: R6.2, U3.3 (ILIM)

Notes on the sheet:
Buck Converter Power Supply
3V3 Regulator
TLV1117LV (1A)

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
